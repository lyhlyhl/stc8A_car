# Keil uVision project text1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: text1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\hardware\delay;..\hardware\IIC;..\hardware\OLED;..\hardware\ADC
  group Main
    ./: STARTUP.A51 text1.c
  group Hardware
    ../hardware/OLED/: OLED.c
    ../hardware/IIC/: I2C.c
    ../hardware/delay/: delay.c
    ../hardware/ADC/: adc.c
