# Keil uVision project text1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: text1 +hex
  c flags: Optimize=2 SizeSpeed=1
  c include: ..\hardware\delay;..\hardware\IIC;..\hardware\OLED;..\hardware\ADC;..\hardware\Mpu6050;..\hardware\KEY;..\hardware\LED;..\hardware\PWM;..\hardware\pca;..\hardware\timer;..\hardware\PID;..\hardware\CCD
  link misc: REMOVEUNUSED
  group Main
    ./: text1.c
  group Hardware
    ../hardware/OLED/: OLED.c
    ../hardware/IIC/: I2C.c
    ../hardware/delay/: delay.c
    ../hardware/ADC/: adc.c
    ../hardware/Mpu6050/: SEEKFREE_MPU6050.c SEEKFREE_IIC.c Kalman_Filter.c
    ../hardware/KEY/: KEY.c
    ../hardware/LED/: LED.c
    ../hardware/PWM/: pwm.c
    ../hardware/PID/: PID.c
    ../hardware/pca/: pca.c
    ../hardware/timer/: timer.c
    ../hardware/CCD/: SEEKFREE_TSL1401.c
