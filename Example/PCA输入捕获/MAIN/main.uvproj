# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\delay;..\GUI;..\HARDWARE\ad;..\HARDWARE\pca;..\HARDWARE\spi;..\HARDWARE\xpt2046;..\MAIN;..\tft
  group main
    ./: main.c
  group delay
    ../delay/: delay.c
  group HARDWARE
    ../HARDWARE/pca/: pca.c
